options:
  parameters:
    author: YD3BRB
    generate_options: qt_gui
    id: FMRadioRTLSDR
    output_language: python
    title: Simple FM Radio
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: tune_freq
  id: variable_qtgui_range
  parameters:
    min_len: '300'
    start: 88e6
    step: 50e3
    stop: 108e6
    value: 105.9e6
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.3'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '25'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: tune_freq
    gain: '32.8'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.7.0
