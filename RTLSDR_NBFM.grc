options:
  parameters:
    author: Mic
    generate_options: qt_gui
    id: VHF_NBFM_RTLSDR
    output_language: python
    title: RTLSDR_VHF_NBFM
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 12e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 144e6
    step: 10e3
    stop: 149e6
    value: 145.6e6
  states: {}
- name: quadrature_rate
  id: variable
  parameters:
    value: 384e3
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '49'
    value: '34'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 384e3
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.3'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: int (quadrature_rate)
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6e3
    decim: int(samp_rate/bandwidth)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: bandwidth/quadrature_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', mmse_resampler_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [mmse_resampler_xx_0, '0', analog_nbfm_rx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
