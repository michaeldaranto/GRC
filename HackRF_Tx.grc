options:
  parameters:
    author: Mic - YD3BRB
    copyright: Copyleft 🄯
    generate_options: qt_gui
    id: HackRF_Tx
    output_language: python
    title: HackRF_Tx
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: int(4.8e4)
  states: {}
- name: quadrature_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: tune_freq
  id: variable_qtgui_range
  parameters:
    min_len: '300'
    start: 144e6
    step: 50e3
    stop: 149e6
    value: 145.6e6
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '2'
    stop: '49'
    value: '32'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: quadrature_rate
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: soundblaster
    samp_rate: '48000'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/4
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: quadrature_rate
    interp: samp_rate
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: tune_freq
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}

connections:
- [analog_nbfm_tx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0_0, '0']
- [audio_source_0, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_0_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
